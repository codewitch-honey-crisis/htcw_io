## zephyr/Kconfig
```kconfig
menu "htcw_io configuration"
  config HTCW_IO
    bool "Enable HTCW_IO"
    default n
  config IO_NO_FS
    bool "Disable filesystem streams"
    default y
endmenu
```
